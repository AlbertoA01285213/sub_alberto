Commit message: Se agrego mission_handler

File: install/uuv_visualization/share/uuv_visualization/urdf/sub.urdf (robot description, URDF)
Before this commit: robot UUV, 2 links, 1 joints
Joints:
- joint base_to_visual: axis (none) -> 0 0 0; origin (none) -> xyz=0.0 0.0 0.0 rpy=0.0 0.0 0.0
